# Keil uVision project smart_remd.uvprojx, settings and files
target smart_remd (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: smart_remd +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Inc;../Drivers/Middlewares/Inc;../Drivers/Hardwares/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c data_base.c time_clocks.c icons.c page_deleted.c page_entering.c page_home.c page_other.c page_setting.c page_warning.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_sram.c stm32f4xx_hal_nor.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_rng.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma_ex.c
  group Drivers/Hardwares
    ../Drivers/Hardwares/Src/: basic.c camera.c ertc.c lcd.c norflash.c rng.c sdcard.c sram.c ths.c touch.c
  group Drivers/Middlewares
    ../Drivers/Middlewares/Src/: chinese_in_norflash.c chinese_on_lcd.c diskio.c ff.c ffunicode_chinese.c input.c input_ui.c jpeg_on_lcd.c malloc_sram.c photo.c ffsystem.c
software components: CMSIS:CORE 5.5.0
